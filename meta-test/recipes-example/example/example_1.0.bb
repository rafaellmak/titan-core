SUMMARY = "Example recipe"
LICENSE = "MIT"
